# Keil uVision project HeartRateMonitor.uvprojx, settings and files
target HeartRateMonitor Configuration (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: HeartRateMonitor Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ..\Inc;        ..\Drivers\STM32F7xx_HAL_Driver\Inc;        ..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;        ..\Drivers\CMSIS\Include;        ..\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma2d.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c fonts.c functions.c touch.c ecg.c
    ../: README.md
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
